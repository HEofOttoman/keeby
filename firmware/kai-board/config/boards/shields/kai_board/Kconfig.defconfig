## firmware/kai-board/config/boards/shields/kai_board/Kconfig.defconfig
```kconfig
if SHIELD_KAI_BOARD

config ZMK_KEYBOARD_NAME
    default "Kai Board Keeb"

endif
```
